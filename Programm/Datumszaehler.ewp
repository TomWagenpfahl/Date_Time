# IAR project Datumszaehler.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: ConsoleHMI.cpp ConsoleHMI.h Counter.h DateTime.cpp DateTime.h HardwareHMI.cpp HardwareHMI.h HMI.h main.cpp ModuloCounter.cpp ModuloCounter.h OffsetCounter.h stm_gpio.cpp stm_gpio.h
